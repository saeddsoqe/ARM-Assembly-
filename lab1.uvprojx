# Keil uVision project lab1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: EFM32GG990F1024 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32GG_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.s
